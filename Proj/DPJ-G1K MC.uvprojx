# Keil uVision project DPJ-G1K MC.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DPJ-G1K MC +hex
  AfterMake: fromelf.exe --bincombined  -o  "$L@L.bin"  "#L"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --locale=english
  c include: ..\LwIP\src\include;..\LwIP\system;..\LIB\STM32F4xx_HAL_Driver\Inc;..\LIB\STM32F4xx_HAL_Driver\Inc\Legacy;..\freeRTOS\portable\RVDS\ARM_CM4F;..\LwIP\src\include\netif\ppp;..\LIB\STM32_USB_Host_Library\Core\Inc;..\LIB\STM32_USB_Host_Library\Class\MSC\Inc;..\LIB\CMSIS\Device\ST\STM32F4xx\Include;..\FatFs\source;..\freeRTOS\include;..\freeRTOS\CMSIS_RTOS;..\LwIP\src\include\lwip;..\LwIP\src\include\lwip\apps;..\LwIP\src\include\lwip\priv;..\LwIP\src\include\lwip\prot;..\LwIP\src\include\netif;..\LwIP\src\include\posix;..\LwIP\src\include\posix\sys;..\LwIP\system\arch;..\LIB\CMSIS\Include;..\BSP;..\APP;..\USR;..\RTT;..\GUI\Config;..\GUI\STemWin\Inc;..\GUI\Win
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MDK-ARM
    ../lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group CMSIS
    ../LIB/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group USR
    ../USR/: main.c sys_Variable.c sys_Tasks.c sys_Init.c
  group APP
    ../APP/: Function.c app_Acquisition.c app_Alarm.c app_PCProto.c app_SUBProto.c app_ETH.c app_Optimset.c app_PTEnergy.c app_TCPClient.c
  group BSP
    ../BSP/: bsp_Fram.c bsp_GPIO.c bsp_ATT.c bsp_UART.c bsp_RTC.c bsp_IWDG.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c stm32f4xx_it.c ethernetif.c fsmc.c SSD1963.c touch.c
  group GUI/Config
    ../GUI/Config/: GUIConf.c LCDConf.c GUIDRV_Template.c GUI_X_OS.c
  group GUI/STemWin/lib
    ../GUI/STemWin/Lib/: STemWin532_CM4_OS_Keil_ot.lib
  group GUI/Fonts
    ../GUI/Fonts/: songti13.c songti15.c songti17.c DPJ.c
  group GUI/Win
    ../GUI/Win/: WindowDLG_BusData.c WindowDLG_Device_Inform.c WindowDLG_History_Alarm.c WindowDLG_History_Energy.c WindowDLG_KeypadUser.c WindowDLG_NowAlarm.c WindowDLG_System_ConS.c WindowDLG_Help.c WindowDLG_Home.c
  group Lwip_core/ipv4
    ../LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Lwip_core
    ../LwIp/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Lwip_api
    ../LwIp/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Lwip_netif
    ../LwIp/src/netif/: ethernet.c
  group FreeRTOS
    ../freeRTOS/CMSIS_RTOS/: cmsis_os.c
    ../freeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../freeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../freeRTOS/portable/MemMang/: heap_4.c
  group STM32F4xx_HAL_Driver
    ../lib/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_ll_fsmc.c
    ../LIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_eth.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_sram.c
  group DOC
    ../DOC/: FRAM地址分配.txt 管脚接口定义.txt USB host及fatfs应用笔记.txt
